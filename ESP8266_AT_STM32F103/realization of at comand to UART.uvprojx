# Keil uVision project realization of at comand to UART.uvprojx, settings and files
target 23.10.2017 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: realization of at comand to UART
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MainCode
    ./: main.h main.cpp
  group Init_Pheriph
    ./: ESP8266_AT.cpp ESP8266_AT.h ESP8266_SendUart.cpp ESP8266_SendUart.h STM32_Flash.cpp STM32_Flash.h STM32_Timer_Library.cpp STM32_Timer_Library.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
