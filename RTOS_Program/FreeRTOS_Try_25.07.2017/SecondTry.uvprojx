# Keil uVision project SecondTry.uvprojx, settings and files
target 25.07.2017 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SecondTry
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FReeRTOS_STM32f100RB\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./Main/: main.c
  group FreeRtos_inc
    ./FReeRTOS_STM32f100RB/include/: deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h task.h timers.h croutine.h portmacro.h StackMacros.h
  group FreeRtos_src
    ./FReeRTOS_STM32f100RB/: croutine.c event_groups.c heap_2.c list.c queue.c tasks.c timers.c port.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
