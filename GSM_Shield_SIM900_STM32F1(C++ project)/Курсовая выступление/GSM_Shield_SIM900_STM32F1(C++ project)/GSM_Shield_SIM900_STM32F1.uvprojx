# Keil uVision project GSM_Shield_SIM900_STM32F1.uvprojx, settings and files
target 16.02.2017 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GSM_Shield_SIM900_STM32F1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\Libriary;.\Main;.\StartUp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./Main/: main.cpp
  group Libriary
    ./Libriary/: delay.cpp delay.h GSMShieldSIM900.cpp Periphery_Init.cpp Periphery_Init.h GSMShieldSIM900.h
  group CMSIS
    ./CMSIS/: system_stm32f10x.c system_stm32f10x.h
    ./CMSIS/CoreSupport/: core_cm3.c core_cm3.h
  group StartUp
    ./StartUp/: core_cm3.h startup_stm32f10x_md_vl.s stm32f10x.h
