# Keil uVision project Keil_p1.uvprojx, settings and files
target SMT32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Keil_p1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Main;.\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x;.\Objects
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./CMSIS/: stm32f10x.h
    ./CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group MainCode
    ./Main/: main.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
