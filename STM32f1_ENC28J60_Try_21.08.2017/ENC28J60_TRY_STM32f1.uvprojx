# Keil uVision project ENC28J60_TRY_STM32f1.uvprojx, settings and files
target 21.08.2017 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ENC28J60_TRY_STM32f1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Main
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./Main/: main.c main.h delay.cpp
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
