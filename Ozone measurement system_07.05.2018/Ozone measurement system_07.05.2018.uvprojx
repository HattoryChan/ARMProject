# Keil uVision project Ozone measurement system_07.05.2018.uvprojx, settings and files
target 07.05.2018 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ozone measurement system_07.05.2018
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Main;.\Hardware;.\CMSIS_Startup\Startup;.\CMSIS_Startup\CMSIS;.\CMSIS_Startup\CMSIS\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./Main/: main.cpp main.h
  group Hardware
    ./Hardware/: GPIO_Init.cpp TIM2_Init.cpp GPIO_Init.h TIM2_Init.h delay.h UART_Init.cpp UART_Init.h TIM4_Init.cpp TIM4_Init.h
  group StartUp_CMSIS
    ./CMSIS_Startup/CMSIS/: system_stm32f10x.c system_stm32f10x.h
    ./CMSIS_Startup/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ./CMSIS_Startup/Startup/: startup_stm32f10x_md_vl.s
