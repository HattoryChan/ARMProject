# Keil uVision project 26.02.2017 Gpio_try.uvprojx, settings and files
target 26.02.2017 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 26.02.2017 Gpio_try +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\Include;.\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Device\ST\STM32F4xx\Source\Templates;.\main;.\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./main/: main.cpp
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h stm32f4xx.h
  group StartUp
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
    ./CMSIS/Include/: core_cm4.h
