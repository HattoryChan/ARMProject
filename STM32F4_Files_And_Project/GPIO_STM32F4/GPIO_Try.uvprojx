# Keil uVision project GPIO_Try.uvprojx, settings and files
target 24.02.2017 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_Try
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\MainCode;.\Startup;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ./MainCode/: main.cpp
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c core_cm3.h
  group StartUp
    ./Startup/: core_cm3.h
