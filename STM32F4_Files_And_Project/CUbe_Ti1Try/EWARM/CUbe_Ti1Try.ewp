# IAR project CUbe_Ti1Try.ewp, settings and files
configuration CUbe_Ti1Try (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100RB ST STM32F100RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F100xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: CUbe_Ti1Try.out
  ILINK.IlinkIcfFile: stm32f100xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/EWARM
    ./:  startup_stm32f100xb.s
  group Application/User
    ./: 
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c
  group Drivers
    ./: 
  group Drivers/STM32F1xx_HAL_Driver
    ./: 
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f1xx.c
