# Keil uVision project 28.02.2017 GPIO Try 2.uvprojx, settings and files
target 28.02.2017 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 28.02.2017 GPIO Try 2
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329 --show_parent_lib --show_full_path
  group main
    ./main/: main.c
  group CMSIS
    ./CMSIS/: core_cm4.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f411xe.s
