# Keil uVision project WithLibrary.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WithLibrary
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\nRF24L01_lib_stm32_gcc;.\stm_lib\inc;.\stm_lib\src;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\gpio
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MainCode
    ./MainCode/: mainCode.c
  group NRF24l01
    ./nrf24/: nrf24.c nrf24.h
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_rcc.c
    ./STM32F10x_StdPeriph_Driver/inc/: stm32f10x_i2c.h stm32f10x_gpio.h stm32f10x_rcc.h
    ./gpio/: gpio.c gpio.h types.h spim.c spim.h delay.c delay.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
