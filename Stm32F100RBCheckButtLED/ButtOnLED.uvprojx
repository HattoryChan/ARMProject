# Keil uVision project ButtOnLED.uvprojx, settings and files
target STM32F100 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ButtOnLED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Startup;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Startup/: stm32f10x.h startup_stm32f10x_md_vl.s core_cm3.h
  group MainCode
    ./MainCode/: main.cpp
  group CMSIS
    ./CMSIS/: system_stm32f10x.c system_stm32f10x.h
    ./CMSIS/CoreSupport/: core_cm3.c
