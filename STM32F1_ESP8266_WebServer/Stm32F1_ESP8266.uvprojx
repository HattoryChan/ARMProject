# Keil uVision project Stm32F1_ESP8266.uvprojx, settings and files
target WebServer (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stm32F1_ESP8266
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS_Startup\CMSIS\CoreSupport;.\MainCode;.\CMSIS_Startup\Startup;.\CMSIS_Startup\CMSIS;.\Hardware_STM32
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS_StartUp
    ./CMSIS_Startup/Startup/: core_cm3.h startup_stm32f10x_md_vl.s stm32f10x.h
    ./CMSIS_Startup/CMSIS/: system_stm32f10x.c system_stm32f10x.h
    ./CMSIS_Startup/CMSIS/CoreSupport/: core_cm3.c
  group MainCode
    ./MainCode/: main.cpp main.h
  group Hardware_STM32
    ./Hardware_STM32/: delay.h ESP8266_AT.cpp ESP8266_AT.h ESP8266_SendUart.h STM32_Timer_Library.cpp STM32_Timer_Library.h ESP8266_SendUart.cpp STM32_Termistor_Library.cpp STM32_Termistor_Library.h STM32_LightAndWaterRelay_Control.cpp STM32_LightAndWaterRelay_Control.h STM32_Flash.cpp STM32_Flash.h 74HC595_InitAndWork.cpp 74HC595_InitAndWork.h
