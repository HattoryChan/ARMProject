# Keil uVision project w5500_STM32F1.uvprojx, settings and files
target 30.01.2018 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: w5500_STM32F1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\W5500\Ethernet\W5500;.\Library;.\W5500\Ethernet;.\W5500;..\w5500;.\CMSIS\CoreSupport;.\CMSIS;.\CMSIS\Startup
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./: main.c main.h
  group Ethernet
    ./W5500/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ./W5500/Ethernet/W5500/: w5500.c w5500.h
  group Library
    ./Library/: spi.c spi.h stm32f10x_conf.h
  group CMSIS
    ./CMSIS/: system_stm32f10x.c system_stm32f10x.h
    ./CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ./CMSIS/Startup/: startup_stm32f10x_md_vl.s stm32f10x.h
