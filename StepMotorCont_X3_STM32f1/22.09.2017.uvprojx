# Keil uVision project 22.09.2017.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 22.09.2017
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\StepMotorCont_X3_STM32f1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./: main.c main.h
  group Pheriph
    ./: UART_InitAndWork.c UART_InitAndWork.h StepMotor_InitAndWork.c StepMotor_InitAndWork.h delay.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
