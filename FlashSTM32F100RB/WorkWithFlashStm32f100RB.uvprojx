# Keil uVision project WorkWithFlashStm32f100RB.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WorkWithFlashStm32f100RB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\Startup;.\MainCode
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MainCode
    ./MainCode/: main.cpp delay.h UsartInitAndRX_TXFUnction.h
  group CMSIS
    ./CMSIS/: system_stm32f10x.c system_stm32f10x.h
    ./CMSIS/CoreSupport/: core_cm3.c core_cm3.h
  group StartUp
    ./Startup/: core_cm3.h startup_stm32f10x_md_vl.s stm32f10x.h
